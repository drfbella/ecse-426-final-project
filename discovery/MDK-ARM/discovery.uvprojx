# Keil uVision project discovery.uvprojx, settings and files
target discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c LIS3DSH.c fput_debug.c
    ../Inc/: LIS3DSH.h
software components: CMSIS:CORE 5.0.1, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:Startup 2.6.0
